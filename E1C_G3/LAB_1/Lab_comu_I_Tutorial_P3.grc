options:
  parameters:
    author: Cuadros_Vanegas_E1C
    generate_options: qt_gui
    id: Lab_comu_1
    output_language: python
    title: Primer Flujograma
  states: {}

blocks:
- name: Amplitud
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '5'
    value: '0'
  states: {}
- name: frecuency
  id: variable
  parameters:
    value: sample_rate/3
  states: {state: disabled}
- name: frecuency
  id: variable_qtgui_range
  parameters:
    start: '-sample_rate/2'
    step: '100'
    stop: sample_rate/2
    value: '0'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitud
    freq: frecuency
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 32e3
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 32e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 32e3
    stemplot: 'True'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
