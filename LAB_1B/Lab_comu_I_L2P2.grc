options:
  parameters:
    author: labcom
    copyright: UIS
    generate_options: qt_gui
    id: Pratica1B
    output_language: python
    title: Generador
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud señal TX
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '0.5'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '500e-3'
    stop: '30'
    value: '10'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    alias: analog_const_source_x_0
    const: A
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    alias: uhd_usrp_sink_0
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
